**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Oct 13, 14
* MODEL FORMAT: SPICE3
.SUBCKT MMBT5550L B E C
Q1 C B E mmbt5550lt1g
.MODEL mmbt5550lt1g npn
+IS=2.06171e-13 BF=317.461 NF=1.0649 VAF=1000
+IKF=0.0116634 ISE=6.06017e-12 NE=1.83468 BR=0.1
+NR=1.5 VAR=1000 IKR=0.116634 ISC=6.06017e-12
+NC=1.31093 RB=0.1 IRB=0.198776 RBM=0.1
+RE=0.0001 RC=1.34106 XTB=0.1 XTI=1
+EG=1.15734 CJE=1.91073e-11 VJE=0.4 MJE=0.361546
+TF=2.25669e-10 XTF=252.028 VTF=13572 ITF=0.0287397
+CJC=7.56371e-12 VJC=0.4 MJC=0.341279 XCJC=0.910308
+FC=0.429655 CJS=0 VJS=0.75 MJS=0.5
+TR=1e-07 PTF=0 KF=0 AF=1
.ENDS MMBT5550L
