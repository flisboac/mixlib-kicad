*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM4.3 K A
X1 A K ZMMx Vznom=4.3 Iztest=5m Vr=1 Ir=100nA Rzj=75 Izmax=109m Cjo=700p
.ends ZMM4.3
