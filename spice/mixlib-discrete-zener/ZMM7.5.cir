*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM7.5 K A
X1 A K ZMMx Vznom=7.45 Iztest=5m Vr=5 Ir=100nA Rzj=7 Izmax=63m Cjo=700p
.ends ZMM7.5
