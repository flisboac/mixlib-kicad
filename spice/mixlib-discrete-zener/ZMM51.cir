*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM51 K A
X1 A K ZMMx Vznom=51.0 Iztest=2.5m Vr=39 Ir=100nA Rzj=125 Izmax=9m Cjo=700p
.ends ZMM51
