*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM9.1 K A
X1 A K ZMMx Vznom=9.05 Iztest=5m Vr=7 Ir=100nA Rzj=10 Izmax=52m Cjo=700p
.ends ZMM9.1
