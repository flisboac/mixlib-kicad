*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM27 K A
X1 A K ZMMx Vznom=27.0 Iztest=5m Vr=20 Ir=100nA Rzj=80 Izmax=17m Cjo=700p
.ends ZMM27
