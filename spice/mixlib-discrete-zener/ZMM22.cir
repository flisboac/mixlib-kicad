*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM22 K A
X1 A K ZMMx Vznom=22.05 Iztest=5m Vr=16 Ir=100nA Rzj=55 Izmax=21m Cjo=700p
.ends ZMM22
