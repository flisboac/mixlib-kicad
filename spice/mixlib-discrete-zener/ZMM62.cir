*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM62 K A
X1 A K ZMMx Vznom=62.0 Iztest=2.5m Vr=47 Ir=100nA Rzj=150 Izmax=8m Cjo=700p
.ends ZMM62
