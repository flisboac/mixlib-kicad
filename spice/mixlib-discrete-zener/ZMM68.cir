*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM68 K A
X1 A K ZMMx Vznom=68.0 Iztest=2.5m Vr=51 Ir=100nA Rzj=200 Izmax=7m Cjo=700p
.ends ZMM68
