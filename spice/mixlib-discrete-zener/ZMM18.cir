*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM18 K A
X1 A K ZMMx Vznom=17.95 Iztest=5m Vr=13 Ir=100nA Rzj=50 Izmax=26m Cjo=700p
.ends ZMM18
