*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM3.3 K A
X1 A K ZMMx Vznom=3.3 Iztest=5m Vr=1 Ir=100nA Rzj=85 Izmax=143m Cjo=700p
.ends ZMM3.3
