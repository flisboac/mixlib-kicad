*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM2.4 K A
X1 A K ZMMx Vznom=2.42 Iztest=5m Vr=1 Ir=100nA Rzj=85 Izmax=195m Cjo=700p
.ends ZMM2.4
