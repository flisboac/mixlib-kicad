*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM11 K A
X1 A K ZMMx Vznom=11.0 Iztest=5m Vr=8 Ir=100nA Rzj=20 Izmax=43m Cjo=700p
.ends ZMM11
