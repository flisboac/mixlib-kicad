*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM47 K A
X1 A K ZMMx Vznom=47.0 Iztest=2.5m Vr=36 Ir=100nA Rzj=110 Izmax=10m Cjo=700p
.ends ZMM47
