*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM10 K A
X1 A K ZMMx Vznom=10.0 Iztest=5m Vr=7 Ir=100nA Rzj=15 Izmax=47m Cjo=700p
.ends ZMM10
