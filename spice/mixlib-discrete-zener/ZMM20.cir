*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM20 K A
X1 A K ZMMx Vznom=20.0 Iztest=5m Vr=15 Ir=100nA Rzj=55 Izmax=24m Cjo=700p
.ends ZMM20
