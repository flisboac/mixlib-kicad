*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM15 K A
X1 A K ZMMx Vznom=14.7 Iztest=5m Vr=11 Ir=100nA Rzj=30 Izmax=32m Cjo=700p
.ends ZMM15
