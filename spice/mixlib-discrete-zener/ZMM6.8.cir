*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM6.8 K A
X1 A K ZMMx Vznom=6.8 Iztest=5m Vr=3 Ir=100nA Rzj=8 Izmax=69m Cjo=700p
.ends ZMM6.8
