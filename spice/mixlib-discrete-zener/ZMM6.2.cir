*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM6.2 K A
X1 A K ZMMx Vznom=6.2 Iztest=5m Vr=2 Ir=100nA Rzj=10 Izmax=76m Cjo=700p
.ends ZMM6.2
