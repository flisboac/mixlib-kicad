*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM36 K A
X1 A K ZMMx Vznom=36.0 Iztest=5m Vr=27 Ir=100nA Rzj=90 Izmax=13m Cjo=700p
.ends ZMM36
