*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM2.7 K A
X1 A K ZMMx Vznom=2.7 Iztest=5m Vr=1 Ir=100nA Rzj=85 Izmax=172m Cjo=700p
.ends ZMM2.7
