*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM13 K A
X1 A K ZMMx Vznom=13.25 Iztest=5m Vr=10 Ir=100nA Rzj=26 Izmax=35m Cjo=700p
.ends ZMM13
