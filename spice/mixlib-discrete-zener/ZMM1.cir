*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM1 K A
X1 A K ZMMx Vznom=0.765 Iztest=5m Vr=0 Ir=100nA Rzj=8 Izmax=400m Cjo=700p
.ends ZMM1
