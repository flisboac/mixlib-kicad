*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM56 K A
X1 A K ZMMx Vznom=56.0 Iztest=2.5m Vr=43 Ir=100nA Rzj=135 Izmax=8m Cjo=700p
.ends ZMM56
