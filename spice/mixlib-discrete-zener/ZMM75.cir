*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM75 K A
X1 A K ZMMx Vznom=74.5 Iztest=2.5m Vr=56 Ir=100nA Rzj=250 Izmax=6m Cjo=700p
.ends ZMM75
