*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM39 K A
X1 A K ZMMx Vznom=39.0 Iztest=2.5m Vr=30 Ir=100nA Rzj=90 Izmax=12m Cjo=700p
.ends ZMM39
