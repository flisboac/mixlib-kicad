*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM4.7 K A
X1 A K ZMMx Vznom=4.7 Iztest=5m Vr=1 Ir=100nA Rzj=60 Izmax=100m Cjo=700p
.ends ZMM4.7
