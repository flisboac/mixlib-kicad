*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM33 K A
X1 A K ZMMx Vznom=33.0 Iztest=5m Vr=24 Ir=100nA Rzj=80 Izmax=14m Cjo=700p
.ends ZMM33
