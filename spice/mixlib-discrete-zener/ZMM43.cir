*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM43 K A
X1 A K ZMMx Vznom=43.0 Iztest=2.5m Vr=33 Ir=100nA Rzj=100 Izmax=11m Cjo=700p
.ends ZMM43
