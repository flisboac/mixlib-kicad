*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM12 K A
X1 A K ZMMx Vznom=12.05 Iztest=5m Vr=9 Ir=100nA Rzj=20 Izmax=39m Cjo=700p
.ends ZMM12
