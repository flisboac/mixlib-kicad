*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM8.2 K A
X1 A K ZMMx Vznom=8.2 Iztest=5m Vr=6 Ir=100nA Rzj=7 Izmax=57m Cjo=700p
.ends ZMM8.2
