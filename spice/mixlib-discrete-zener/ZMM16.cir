*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM16 K A
X1 A K ZMMx Vznom=16.2 Iztest=5m Vr=12 Ir=100nA Rzj=40 Izmax=29m Cjo=700p
.ends ZMM16
