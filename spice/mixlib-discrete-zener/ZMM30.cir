*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM30 K A
X1 A K ZMMx Vznom=30.0 Iztest=5m Vr=22 Ir=100nA Rzj=80 Izmax=16m Cjo=700p
.ends ZMM30
