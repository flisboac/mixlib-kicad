*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM24 K A
X1 A K ZMMx Vznom=24.2 Iztest=5m Vr=18 Ir=100nA Rzj=70 Izmax=20m Cjo=700p
.ends ZMM24
