*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM5.1 K A
X1 A K ZMMx Vznom=5.1 Iztest=5m Vr=1 Ir=100nA Rzj=35 Izmax=93m Cjo=700p
.ends ZMM5.1
