*
* This file was autogenerated. Check data/gen_ZMM1.py for more details.
*
.include include/ZMMx.cir
.subckt ZMM5.6 K A
X1 A K ZMMx Vznom=5.6 Iztest=5m Vr=1 Ir=100nA Rzj=25 Izmax=83m Cjo=700p
.ends ZMM5.6
