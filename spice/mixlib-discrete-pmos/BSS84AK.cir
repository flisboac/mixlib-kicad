*****************************************************************
* NXP BSS84AK
*
* Polarity P-Channel
* Ratings 50V/4.50E+00OHMS/0.18A
*
* Date Created Thu Apr  7 07:37:44 2011
*
*****************************************************************
* Model Generated by Transim Technology
*           Copyright(c) 2004
*         All Rights Reserved
*    UNPUBLISHED LICENSED SOFTWARE
*           www.transim.com
*
* Contains Proprietary Information Which
* is The Property of Transim or it's licensees.
*
* Commercial Use or Resale Restricted by
* Transim License Agreement.
*
*****************************************************************

.SUBCKT BSS84AK GATE SOURCE DRAIN

LD DRAIN 5 4e-10
RLD2 DRAIN 5 1.0053088
RLD1 5 4 0.0023
LG GATE 1 8.81711084834576e-10
RLG GATE 1 2.21597978160436
LS SOURCE 8 1.37135823401249e-09
RLS2 SOURCE 8 3.44659625151304
RLS1 8 7 0.0585579563006914

RDS 7 4 50000000000 TC=-0.05

RS 6 7 0.0001

RD 3 4 3.40064204369931 TC=0.0107436954098734,-5.13207197144137e-06
RBD 9 4 0.114762406260949 TC=0.0107436954098734,-5.13207197144137e-06
DBD 9 7 DBD

M1 3 2 6 6 MINT

RGS 2 6 38095238.0952381
CGS 2 6 2.37e-11
RG 1 2 19.9470486389713

* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    2 3 VALUE { V(13, 0)*I(V11) }
E11    12   0  2 3  1
E12    13   0  TABLE {V(12)}
+ -20	19.46
+ -15	19.50
+ -10	19.85
+ -5	20.39
+ -4	20.35
+ -3	19.61
+ -2	14.64
+ -1	7.77
+ -0.5	5.76
+ -0.2	4.69
+ -0.1	4.37
+ 0	4.08
+ 0.1	3.78
+ 0.2	3.51
+ 0.5	2.89
+ 1	2.42
+ 2	2.1
+ 3	1.94
+ 4	1.84
+ 5	1.76
+ 6	1.71
+ 8	1.62
+ 10	1.55
+ 12	1.5
+ 15	1.43
+ 20	1.35
+ 30	1.25
+ 40	1.19

.MODEL MINT PMOS(Vto=-1.66 Kp=1.3807e-01 Nfs=1000000000 Eta=0
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8  Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=3000)
*+ U0=600 Vmax=1000)

.MODEL DBD D(Bv=63.00 Ibv=2.00E-06 Rs=1E-6 Is=1.48118796889277e-15
+ N=1 M=0.33 VJ=0.53 Fc=0.5 Cjo=1.144e-11 Tt=1.85e-08)

.ENDS BSS84AK
